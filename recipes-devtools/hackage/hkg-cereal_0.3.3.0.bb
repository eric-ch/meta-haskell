DESCRIPTION = "A binary serialization library, similar to binary, that introduces an isolate primitive for parser isolation, and labeled blocks for better error messages."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5ec64b8b2cb5d58bfa9e4662374b9108"

inherit hackage

SRC_URI[md5sum] = "70d24b61194880df3ec798ad89a21a7b"
SRC_URI[sha256sum] = "7e94e9b337f9372289839ceeefb255ac671802904ebdfe01aee7fcb51d2e0d2f"

PR = "r1"
