SUMMARY = "A UTF8 layer for IO and Strings."
DESCRIPTION = "The utf8-string package provides operations for encoding UTF8 strings to Word8 lists and back, and for reading and writing UTF8 without truncation."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8061b32e50a7a7433f0c7bd9f431ca96"

inherit hackage

SRC_URI[md5sum] = "72d13d9453cdf721dd95bc18144a120a"
SRC_URI[sha256sum] = "f97027354f0b88af9bf3638aee0eb3bb72c05ec44f4af4c1abe070597059a5bd"

PR = "r1"
