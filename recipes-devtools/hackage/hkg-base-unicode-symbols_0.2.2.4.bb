DESCRIPTION = "This package defines new symbols for a number of functions, operators and types in the base package."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=91b1bcbe3d4f36632f0400276e50e1dc"

inherit hackage

SRC_URI[md5sum] = "7faf43a94a0082ee2fe7971fabd9be21"
SRC_URI[sha256sum] = "a2f841430fec32edba778b74bde83bf0170ada7c5e2e59d7187c8f06d92dcca9"

PR = "r1"
