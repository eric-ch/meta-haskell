DESCRIPTION = "A variety of alternative parser combinator libraries, including the original HuttonMeijer set. The Poly sets have features like good error reporting, arbitrary token type, running state, lazy parsing, and so on. Finally, Text.Parse is a proposed replacement for the standard Read class, for better deserialisation of Haskell values from Strings."
LICENSE = "LGPL"
LIC_FILES_CHKSUM = "file://COPYRIGHT;md5=b0c0e150083a5c140eda79fd10acf348"

inherit hackage

SRC_URI[md5sum] = "1783867124b49eefdbdc9ac39caf3174"
SRC_URI[sha256sum] = "6e599fb0771e8ce2e1d3a3bbe5eddc2d77b2b4bbb54602f01005dc55dc039d44"

PR = "r1"
