# Python 3 or later is not yet supported.
EXTRA_OECONF_append_class-native = " --python=/usr/bin/python2"

